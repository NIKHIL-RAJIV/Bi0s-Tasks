options:
  parameters:
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '76800'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '16'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '500'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '48000'
    decim: '16'
    samp_rate: '76800'
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*16), 2000)
    type: fcf
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: '48000'
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [zeromq_sub_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
